## package/python-mpf/Config.in
```kconfig
config BR2_PACKAGE_PYTHON_MPF
	bool "python-mpf"
	help
	  The Mission Pinball Framework.

	  https://www.missionpinball.org/
```
